# Keil uVision project TFTLCD.uvprojx, settings and files
target TFTLCD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TFTLCD +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H750xx
  c include: ..\CMSIS\CoreSupport;..\CMSIS\DeviceSupport;..\Project;..\STM32H7xx_HAL_Driver\Inc;..\User\delay;..\User\LED;..\User\KEY;..\User\usart;..\User\LCD;..\User\stm32h7xx_it;..\User\system;..\User\TMP275;..\User\EXTI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group main
    ./: main.c
    ../User/stm32h7xx_it/: stm32h7xx_it.c
    ../CMSIS/DeviceSupport/: system_stm32h7xx.c
  group User
    ../User/LED/: led.c
    ../User/delay/: delay.c
    ../User/KEY/: key.c
    ../User/LCD/: lcd.c
    ../User/usart/: usart.c
    ../User/system/: system.c
    ../User/TMP275/: tmp275.c
    ../User/EXTI/: exti.c
  group HAL_Driver
    ../STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c
  group CMSIS
    ../CMSIS/CoreSupport/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h core_cm7.h
    ../CMSIS/DeviceSupport/: startup_stm32h750xx.s
